## config/boards/shields/rabbit36/Kconfig.defconfig
```kconfig
if RABBIT36

config ZMK_KEYBOARD_NAME
    default "rabbit36"

config SPI
	default y

endif
```
